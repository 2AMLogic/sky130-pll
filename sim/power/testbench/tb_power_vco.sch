v {xschem version=3.4.7 file_version=1.2
* tb_power_vco.sch -- sky130 vco_ring5 supply-current campaign (issue #233)
* GENERATED by sim/power/build.py from its stage table; do not hand-edit.
*
* design/vco/vco_ring5.sch driven open-loop by a staged VCTRL ladder; i(V1) is the VCO's own VDD current (VCTRL source, .ic card and the absent CLK load draw nothing from V1).
*
* V1 is the ONLY supply source on the DUT's VDD net, so i(V1) is the block's
* own supply current. The stimulus (staged sources, idle stage first) is the
* drawn stimulus sources; sim/power/testbench/vco.stages.json is the
* machine-readable stage table the reducer uses.
*
* Provenance: adapted from sim/vco-supply-pushing/testbench/tb_vco_pushing.sch
* (this repo, issue #165): same label-pin wiring, V1 supply, DUT instance style.
}
G {}
V {}
S {}
E {}

C {design/vco/vco_ring5.sym} 0 0 0 0 {name=XXVCO}
C {devices/lab_pin.sym} 0 -80 0 0 {name=p1 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 0 80 0 0 {name=p2 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} -130 0 0 0 {name=p3 sig_type=std_logic lab=VCTRL}
C {devices/lab_pin.sym} 130 0 0 0 {name=p4 sig_type=std_logic lab=CLK}
C {devices/vsource.sym} 600 0 0 0 {name=V1 value=1.8 savecurrent=false}
C {devices/lab_pin.sym} 600 -30 0 0 {name=pv1 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 600 30 0 0 {name=lg1 lab=GND}
C {devices/vsource.sym} 800 0 0 0 {name=V2 value="pwl(0n 0.0 100n 0.0 102n 0.7 350n 0.7 352n 0.725 600n 0.725 602n 0.75 850n 0.75 852n 0.775 1100n 0.775 1102n 0.8 1350n 0.8 1352n 0.825 1600n 0.825 1602n 0.85 1850n 0.85 1852n 0.875 2100n 0.875 2102n 0.9 2350n 0.9 2352n 0.95 2600n 0.95 2602n 1.0 2850n 1.0 2852n 1.2 3100n 1.2 3102n 1.6)" savecurrent=false}
C {devices/lab_pin.sym} 800 -30 0 0 {name=ps1 sig_type=std_logic lab=VCTRL}
C {devices/gnd.sym} 800 30 0 0 {name=lgs1 lab=GND}
C {devices/code.sym} 1300 300 0 0 {name=EXTRA
only_toplevel=true
value="
.ic v(xxxvco.ring0)=0
"
spice_ignore=false}
C {devices/title.sym} -200 500 0 0 {name=lt author="2AM Logic (issue #233, sky130 vco_ring5 supply-current campaign)"}
