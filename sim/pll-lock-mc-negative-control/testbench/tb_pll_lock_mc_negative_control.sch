v {xschem version=3.4.7 file_version=1.2
* tb_pll_lock_mc_negative_control.sch -- T1 item 6's negative control for
* sim/pll-lock-mc's campaign: the SAME testbench, with a DELIBERATELY DEGRADED
* DUT.
*
* Generated by sim/pll-lock-mc-negative-control/testbench/gen_tb.py from
* sim/pll-lock-mc/testbench/tb_pll_lock_mc.sch. The body below is that file's own,
* verbatim, with exactly one substitution: the XXTOP instance's symbol
* (sim/lf-c2-jitter-sensitivity/testbench/top_c2div4.sym instead of
* design/top/top.sym). Supply, the 10 MHz reference, the power-on reset
* stimulus and the NSEL[5:0]=011000 (N=25) strapping are bit-identical to the
* campaign's, and like it this schematic carries no `.tran` card -- the window
* comes from this unit's tb.json via sim/harness/measure.py.
*
* The degraded DUT is the arm sim/lf-c2-jitter-sensitivity MEASURED, not a
* fresh copy of it: see gen_tb.py's own docstring for why this points at that
* unit's committed symbol rather than duplicating the netlist.
*
* Nothing under design/ instantiates any of it, and no spec row is claimed for
* it. Its whole purpose is to be worse than the design at exactly one thing.
}
G {}
V {}
S {}
E {}
C {sim/lf-c2-jitter-sensitivity/testbench/top_c2div4.sym} 0 0 0 0 {name=XXTOP}
C {devices/lab_pin.sym} 0 -240 0 0 {name=p1 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 0 240 0 0 {name=p2 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} -130 -180 0 0 {name=p3 sig_type=std_logic lab=REF}
C {devices/lab_pin.sym} -130 -140 0 0 {name=p4 sig_type=std_logic lab=RESETB}
C {devices/lab_pin.sym} -130 -100 0 0 {name=p5 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} -130 -60 0 0 {name=p6 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} -130 -20 0 0 {name=p7 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} -130 20 0 0 {name=p8 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -130 60 0 0 {name=p9 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -130 100 0 0 {name=p10 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 130 0 0 0 {name=p11 sig_type=std_logic lab=CLK}
C {devices/vsource.sym} 600 0 0 0 {name=V1 value=1.8 savecurrent=false}
C {devices/lab_pin.sym} 600 -30 0 0 {name=p12 sig_type=std_logic lab=VDD}
C {devices/gnd.sym} 600 30 0 0 {name=l1 lab=GND}
C {devices/vsource.sym} 800 0 0 0 {name=V2 value="pulse(0 1.8 0 1n 1n 48n 100n)" savecurrent=false}
C {devices/lab_pin.sym} 800 -30 0 0 {name=p13 sig_type=std_logic lab=REF}
C {devices/gnd.sym} 800 30 0 0 {name=l2 lab=GND}
C {devices/vsource.sym} 1000 0 0 0 {name=V3 value="pwl(0 0 5n 0 6n 1.8)" savecurrent=false}
C {devices/lab_pin.sym} 1000 -30 0 0 {name=p14 sig_type=std_logic lab=RESETB}
C {devices/gnd.sym} 1000 30 0 0 {name=l3 lab=GND}
C {devices/code.sym} 1300 300 0 0 {name=MODELS
only_toplevel=true
format="tcleval( @value )"
value="
** sky130 PDK model include (tt corner) -- patched per-trial by sim/harness
.lib $::SKYWATER_MODELS/sky130.lib.spice tt
** sky130_fd_sc_hd standard-cell subcircuit deck -- design/divider's cells
** need it; the primitive-device .lib above does not define these subckt
** bodies. See sim/pll/testbench/tb_pll.sch's identical include.
.include $::SKYWATER_STDCELLS/sky130_fd_sc_hd.spice
** No .tran/.print card here on purpose -- sim/harness/measure.py injects
** the analysis from this manifest's own measure block (transient window,
** waveform dump, completion marker). See this file's header comment.
"
spice_ignore=false}
C {devices/title.sym} -200 500 0 0 {name=l4 author="2AM Logic (issue #20, sky130 PLL Monte Carlo period-jitter testbench)"}
