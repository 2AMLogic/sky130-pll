v {xschem version=3.4.7 file_version=1.2
* top_c2div4.sch -- design/top/top.sch with its loop filter replaced by the
* DELIBERATELY DEGRADED loop_filter_c2div4.sym (C2 area / 4). NOT part of the
* design.
*
* Generated by sim/lf-c2-jitter-sensitivity/testbench/gen_c2_variant.py from
* design/top/top.sch. The body below is that file's own, verbatim, with
* exactly one substitution: the XLF instance's symbol. Every other instance,
* net, label and property -- the VCO, the PFD/charge pump, the divider, and
* all of the top-level wiring -- is unchanged, so this variant differs from the
* real closed-loop PLL in one loop-filter capacitor's area and in nothing else.
G {}
V {}
S {}
E {}
C {design/pfd-cp/pfd_cp.sym} 0 0 0 0 {name=XPFDCP}
C {sim/lf-c2-jitter-sensitivity/testbench/loop_filter_c2div4.sym} 900 0 0 0 {name=XLF}
C {design/vco/vco_ring5.sym} 1800 0 0 0 {name=XVCO}
C {design/divider/divider_intN.sym} 1800 900 0 0 {name=XDIV}
C {devices/lab_pin.sym} 130 0 0 0 {name=p1 sig_type=std_logic lab=CP}
C {devices/lab_pin.sym} 770 0 0 0 {name=p2 sig_type=std_logic lab=CP}
C {devices/lab_pin.sym} 1030 0 0 0 {name=p3 sig_type=std_logic lab=VCTRL}
C {devices/lab_pin.sym} 1670 0 0 0 {name=p4 sig_type=std_logic lab=VCTRL}
C {devices/lab_pin.sym} -130 40 0 0 {name=p5 sig_type=std_logic lab=FBCLK}
C {devices/lab_pin.sym} 1930 900 0 0 {name=p6 sig_type=std_logic lab=FBCLK}
C {devices/lab_pin.sym} 1670 760 0 0 {name=p7 sig_type=std_logic lab=CLK}
C {devices/lab_pin.sym} 1800 -80 0 0 {name=p8 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1800 720 0 0 {name=p9 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 900 80 0 0 {name=p10 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 1800 80 0 0 {name=p11 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 1800 1080 0 0 {name=p12 sig_type=std_logic lab=GND}
C {devices/iopin.sym} 0 -120 0 0 {name=p13 lab=VDD}
C {devices/iopin.sym} 0 120 0 0 {name=p14 lab=GND}
C {devices/ipin.sym} -130 -40 0 0 {name=p15 lab=REF}
C {devices/ipin.sym} 1670 800 0 0 {name=p16 lab=RESETB}
C {devices/ipin.sym} 1670 840 0 0 {name=p17 lab=NSEL0}
C {devices/ipin.sym} 1670 880 0 0 {name=p18 lab=NSEL1}
C {devices/ipin.sym} 1670 920 0 0 {name=p19 lab=NSEL2}
C {devices/ipin.sym} 1670 960 0 0 {name=p20 lab=NSEL3}
C {devices/ipin.sym} 1670 1000 0 0 {name=p21 lab=NSEL4}
C {devices/ipin.sym} 1670 1040 0 0 {name=p22 lab=NSEL5}
C {devices/opin.sym} 1930 0 0 0 {name=p23 lab=CLK}
C {devices/title.sym} -200 1400 0 0 {name=l1 author="2AM Logic (issue #28, sky130 PLL top-level integration)"}
